options:
  parameters:
    author: Gonzalo Mansilla
    generate_options: qt_gui
    id: receptor_fm
    output_language: python
    title: Receptor FM
  states: {}

blocks:
- name: frec_cent
  id: variable
  parameters:
    value: 93e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: sample_rate_audio
  id: variable
  parameters:
    value: 40e3
  states: {}
- name: sample_rate_deci
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: sint_fino
  id: variable_qtgui_range
  parameters:
    gui_hint: (0,0)
    start: frec_cent-(samp_rate/2)
    step: 50e3
    stop: frec_cent+(samp_rate/2)
    value: frec_cent
  states: {}
- name: sintonia
  id: variable_qtgui_range
  parameters:
    label: Sintonia
    start: 93e6
    step: 1e6
    stop: 104e6
    value: 93e6
  states: {state: disabled}
- name: vol
  id: variable_qtgui_range
  parameters:
    gui_hint: (0,1)
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-sint_fino+frec_cent'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: 4e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: sint_fino-frec_cent
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-2e6'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: int(sample_rate_deci/sample_rate_audio)
    deemph_tau: '75e-6'
    quad_rate: sample_rate_deci
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: int(sample_rate_audio)
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {state: disabled}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: int(samp_rate/sample_rate_deci)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: frec_cent
    fftsize: '1024'
    gui_hint: tab_widget@0
    label1: Sintonia
    label2: '''Espectro de radio'''
    nconnections: '2'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate_deci
    fc: '0'
    fftsize: '1024'
    gui_hint: tab_widget@1
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab_widget@2
    label1: Canal Izquierdo
    label2: Canal Derecho
    nconnections: '2'
    size: '1024'
    srate: sample_rate_audio
    type: float
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    bandwidth: samp_rate
    center_freq: frec_cent
    gain: '20'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: tab_widget
  id: qtgui_tab_widget
  parameters:
    gui_hint: (1,0,15,2)
    label0: Dial - Sintonia
    label1: Frecuencimetro FI
    label2: Señal de sonido vs Tiempo
    num_tabs: '3'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_1, '0', qtgui_freq_sink_x_0, '0']
- [analog_sig_source_x_1, '0', blocks_add_xx_0, '2']
- [analog_wfm_rcv_pll_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_rcv_pll_0, '0', qtgui_time_sink_x_0, '0']
- [analog_wfm_rcv_pll_0, '1', blocks_multiply_const_vxx_0_0, '0']
- [analog_wfm_rcv_pll_0, '1', qtgui_time_sink_x_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_correctiq_0, '0', blocks_multiply_xx_0, '0']
- [blocks_correctiq_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '1']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_pll_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [soapy_hackrf_source_0, '0', blocks_correctiq_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
